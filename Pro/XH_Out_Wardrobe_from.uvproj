# Keil uVision project XH_Out_Wardrobe_from.uvproj, settings and files
target XH_Out_Wardrobe_from (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: XH_Out_Wardrobe_from +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\SYSTEM;..\HARDWARE\key;..\HARDWARE\rs485;..\HARDWARE\timer;..\HARDWARE\motor
  group HARDWARE
    ../HARDWARE/: main.c process.c
    ../HARDWARE/rs485/: rs485.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/timer/: timer.c
  group SYSTEM
    ./: STARTUP.A51
    ../SYSTEM/: delay.c utility.c
  group Doc
    ../: README.md
