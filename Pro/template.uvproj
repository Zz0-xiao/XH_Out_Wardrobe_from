# Keil uVision project template.uvproj, settings and files
target template (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE;..\SYSTEM;..\HARDWARE\led;..\HARDWARE\rs485
  group HARDWARE
    ../HARDWARE/: main.c
    ../HARDWARE/rs485/: rs485.c
  group SYSTEM
    ./: STARTUP.A51
    ../SYSTEM/: delay.c
  group Doc
    ../: README.TXT
